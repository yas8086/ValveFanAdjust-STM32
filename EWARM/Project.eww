<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\2.5KW_FC_Control_Plane.ewp</path>
  </project>
  <batchBuild />
</workspace>
